FILESEXTRAPATHS:prepend := "${THISDIR}/test:"
SRC_URI += "file://remove-md-faulty-config.cfg"
